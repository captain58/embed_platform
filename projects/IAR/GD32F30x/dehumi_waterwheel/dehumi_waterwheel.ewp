# IAR project dehumi_waterwheel.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xC GD GD32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: VECT_TAB_OFFSET=0x6000; USE_HAL_DRIVER; SYSINFO_OS_VERSION="APP-1.0.0"; SYSINFO_PRODUCT_MODEL="ALI_AOS_STM32L476RGTx"; SYSINFO_DEVICE_NAME="STM32L476RGTx"; SYSINFO_KERNEL_VERSION="AOS-R-1.3.3"; SYSINFO_APP_VERSION="APP-1.0.0"; STDIO_UART=0; __BSD_VISIBLE; RHINO_CONFIG_TICK_TASK=0; _TIMESPEC_DEFINED; SAL_USE_AOS_HAL; AOS_ATCMD; _PLATFORM_ALIOS; _NOBOOT_; DEBUG; GD32F30X_HD
  ICCARM.CCDiagSuppress: Pe167,Pe144,Pe513,Pe177,Pe550,Pe188,pe021
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\include\aos\hal; ..\..\..\..\include\network; ..\..\..\..\platform\arch\arm\armv7m\common; ..\..\..\..\platform\mcu\GD32F30x\Drivers\CMSIS; ..\..\..\..\board\GD32F30x-asw\aos; ..\..\..\..\board\GD32F30x-asw\hal; ..\..\..\..\board\GD32F30x-asw\Inc; ..\..\..\..\board\GD32F30x-asw; ..\..\..\..\kernel\rhino\include; ..\..\..\..\kernel\debug\include; ..\..\..\..\kernel\init\include; ..\..\..\..\kernel\debug; ..\..\..\..\kernel\fs\vfs; ..\..\..\..\kernel\fs\vfs\include; ..\..\..\..\network\yloop\include; ..\..\..\..\network\yloop\hal; ..\..\..\..\network\netmgr\include; ..\..\..\..\network\nal\atparser; ..\..\..\..\middleware\linkkit\sdk-c\src\services\mdal\sal; ..\..\..\..\middleware\uagent\ulog\include; ..\..\..\..\middleware\linkkit\sdk-c\src\services\mdal\sal\include; ..\..\..\..\middleware\log; ..\..\..\..\middleware\atmodem; ..\..\..\..\middleware\linkkit\sdk-c\include; ..\..\..\..\utility; ..\..\..\..\utility\libc\compilers\iar; ..\..\..\..\utility\activation; ..\..\..\..\utility\activation\chip_code; config; inc; app; ..\..\..\..\platform\mcu\GD32F30x\hal\inc; ..\..\..\..\platform\mcu\GD32F30x\Drivers\GD32F30x_standard_peripheral\Include; ..\..\..\..\drivers\GD32F30x; ..\..\..\..\platform\mcu\GD32F30x\Drivers\CMSIS\GD\GD32F30x\Include; ..\..\..\..\drivers\GD32F30x\inc; ..\..\..\..\platform\mcu\GD32F30x; ..\..\..\..\platform\arch; config; ..\..\..\..\middleware\frm; linked; archives
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\board\stm32l476vg-wxrtu\aos; ..\..\..\..\kernel\debug\include
  OBJCOPY.OOCOutputFile: dehumi_watertank.bin
  ILINK.IlinkOutputFile: testL476_IAR_V7.out
  ILINK.IlinkIcfFile: icf\GD32F303xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug_86 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L476VG ST STM32L476VG
  ICCARM.CCDefines: VECT_TAB_OFFSET=0x6000; USE_HAL_DRIVER; STM32L476xx; SYSINFO_OS_VERSION="APP-1.0.0"; SYSINFO_PRODUCT_MODEL="ALI_AOS_STM32L476RGTx"; SYSINFO_DEVICE_NAME="STM32L476RGTx"; SYSINFO_KERNEL_VERSION="AOS-R-1.3.3"; SYSINFO_APP_VERSION="APP-1.0.0"; STDIO_UART=0; __BSD_VISIBLE; RHINO_CONFIG_TICK_TASK=0; _TIMESPEC_DEFINED; SAL_USE_AOS_HAL; AOS_ATCMD; _PLATFORM_ALIOS; WITH_SAL; AOS_COMP_ULOG; _NOBOOT_; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\include\aos\hal; ..\..\..\..\include\network; ..\..\..\..\platform\arch\arm\armv7m\common; ..\..\..\..\platform\mcu\stm32l4xx_cube\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\platform\mcu\stm32l4xx_cube\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\platform\mcu\stm32l4xx_cube\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\platform\mcu\stm32l4xx_cube\Drivers\CMSIS\Include; ..\..\..\..\platform\mcu\stm32l4xx_cube\src\STM32L476RG-Nucleo\helloworld; ..\..\..\..\board\stm32l476vg-wxrtu\aos; ..\..\..\..\board\stm32l476vg-wxrtu\hal; ..\..\..\..\board\stm32l476vg-wxrtu\Inc; ..\..\..\..\board\stm32l476vg-wxrtu; ..\..\..\..\kernel\rhino\include; ..\..\..\..\kernel\debug\include; ..\..\..\..\kernel\init\include; ..\..\..\..\kernel\fs\kv\include; ..\..\..\..\kernel\fs\kv; ..\..\..\..\kernel\debug; ..\..\..\..\kernel\fs\vfs; ..\..\..\..\kernel\fs\vfs\include; ..\..\..\..\drivers\sal\wifi\mk3060; ..\..\..\..\drivers\stm32L476; ..\..\..\..\drivers\stm32L476\inc; ..\..\..\..\drivers\sal; ..\..\..\..\drivers\bluetooth\LSB4BT_x74M; ..\..\..\..\network\yloop\include; ..\..\..\..\network\yloop\hal; ..\..\..\..\network\netmgr\include; ..\..\..\..\network\nal\atparser; ..\..\..\..\middleware\linkkit\sdk-c\src\services\mdal\sal; ..\..\..\..\middleware\uagent\ulog\include; ..\..\..\..\middleware\linkkit\sdk-c\src\services\mdal\sal\include; ..\..\..\..\middleware\log; ..\..\..\..\middleware\atmodem; ..\..\..\..\middleware\linkkit\sdk-c\include; ..\..\..\..\utility; ..\..\..\..\utility\libc\compilers\iar; ..\..\..\..\utility\activation; ..\..\..\..\utility\activation\chip_code; config; inc; app
  ICCARM.CCOptLevel: 2
  OBJCOPY.OOCOutputFile: asw02.bin
  ILINK.IlinkIcfFile: icf/stm32l476xx_flash.icf
configuration debug_slave (ARM, debug)
  as the first configuration, except:
configuration debug_wheel (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: GD32F303xB GD GD32F303xB
  ICCARM.CCDefines: VECT_TAB_OFFSET=0x6000; USE_HAL_DRIVER; SYSINFO_OS_VERSION="APP-1.0.0"; SYSINFO_PRODUCT_MODEL="ALI_AOS_STM32L476RGTx"; SYSINFO_DEVICE_NAME="STM32L476RGTx"; SYSINFO_KERNEL_VERSION="AOS-R-1.3.3"; SYSINFO_APP_VERSION="APP-1.0.0"; STDIO_UART=0; __BSD_VISIBLE; RHINO_CONFIG_TICK_TASK=0; _TIMESPEC_DEFINED; SAL_USE_AOS_HAL; AOS_ATCMD; _PLATFORM_ALIOS; _NOBOOT_; DEBUG; GD32F30X_HD; MASTER_NODE
  ICCARM.CCDiagSuppress: Pe167,Pe144,Pe513,Pe177,Pe550,Pe188,pe021,Pe069
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\include\aos\hal; ..\..\..\..\include\network; ..\..\..\..\platform\arch\arm\armv7m\common; ..\..\..\..\platform\mcu\GD32F30x\Drivers\CMSIS; ..\..\..\..\board\GD32F30xC-dehumi\aos; ..\..\..\..\board\GD32F30xC-dehumi\hal; ..\..\..\..\board\GD32F30xC-dehumi\Inc; ..\..\..\..\board\GD32F30xC-dehumi; ..\..\..\..\kernel\rhino\include; ..\..\..\..\kernel\debug\include; ..\..\..\..\kernel\init\include; ..\..\..\..\kernel\debug; ..\..\..\..\kernel\fs\vfs; ..\..\..\..\kernel\fs\vfs\include; ..\..\..\..\network\yloop\include; ..\..\..\..\network\yloop\hal; ..\..\..\..\network\netmgr\include; ..\..\..\..\network\nal\atparser; ..\..\..\..\middleware\linkkit\sdk-c\src\services\mdal\sal; ..\..\..\..\middleware\uagent\ulog\include; ..\..\..\..\middleware\linkkit\sdk-c\src\services\mdal\sal\include; ..\..\..\..\middleware\log; ..\..\..\..\middleware\atmodem; ..\..\..\..\middleware\linkkit\sdk-c\include; ..\..\..\..\utility; ..\..\..\..\utility\libc\compilers\iar; ..\..\..\..\utility\activation; ..\..\..\..\utility\activation\chip_code; config_w; inc; app; ..\..\..\..\platform\mcu\GD32F30x\hal\inc; ..\..\..\..\platform\mcu\GD32F30x\Drivers\GD32F30x_standard_peripheral\Include; ..\..\..\..\drivers\GD32F30x; ..\..\..\..\platform\mcu\GD32F30x\Drivers\CMSIS\GD\GD32F30x\Include; ..\..\..\..\drivers\GD32F30x\inc; ..\..\..\..\platform\mcu\GD32F30x; ..\..\..\..\platform\arch; ..\..\..\..\middleware\frm; linked; archives
  OBJCOPY.OOCOutputFile: dehumi_waterwheel-09.bin
  ILINK.IlinkIcfFile: icf\GD32F303xB.icf
configuration debug_tank (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: VECT_TAB_OFFSET=0; USE_HAL_DRIVER; SYSINFO_OS_VERSION="APP-1.0.0"; SYSINFO_PRODUCT_MODEL="ALI_AOS_STM32L476RGTx"; SYSINFO_DEVICE_NAME="STM32L476RGTx"; SYSINFO_KERNEL_VERSION="AOS-R-1.3.3"; SYSINFO_APP_VERSION="APP-1.0.0"; STDIO_UART=0; __BSD_VISIBLE; RHINO_CONFIG_TICK_TASK=0; _TIMESPEC_DEFINED; SAL_USE_AOS_HAL; AOS_ATCMD; _PLATFORM_ALIOS; _NOBOOT_; DEBUG; GD32F30X_HD
  ICCARM.CCDiagSuppress: Pe167,Pe144,Pe513,Pe177,Pe550,Pe188,pe021,Pe069
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\include\aos\hal; ..\..\..\..\include\network; ..\..\..\..\platform\arch\arm\armv7m\common; ..\..\..\..\platform\mcu\GD32F30x\Drivers\CMSIS; ..\..\..\..\board\GD32F30xC-dehumi\aos; ..\..\..\..\board\GD32F30xC-dehumi\hal; ..\..\..\..\board\GD32F30xC-dehumi\Inc; ..\..\..\..\board\GD32F30xC-dehumi; ..\..\..\..\kernel\rhino\include; ..\..\..\..\kernel\debug\include; ..\..\..\..\kernel\init\include; ..\..\..\..\kernel\debug; ..\..\..\..\kernel\fs\vfs; ..\..\..\..\kernel\fs\vfs\include; ..\..\..\..\network\yloop\include; ..\..\..\..\network\yloop\hal; ..\..\..\..\network\netmgr\include; ..\..\..\..\network\nal\atparser; ..\..\..\..\middleware\linkkit\sdk-c\src\services\mdal\sal; ..\..\..\..\middleware\uagent\ulog\include; ..\..\..\..\middleware\linkkit\sdk-c\src\services\mdal\sal\include; ..\..\..\..\middleware\log; ..\..\..\..\middleware\atmodem; ..\..\..\..\middleware\linkkit\sdk-c\include; ..\..\..\..\utility; ..\..\..\..\utility\libc\compilers\iar; ..\..\..\..\utility\activation; ..\..\..\..\utility\activation\chip_code; config; inc; app; ..\..\..\..\platform\mcu\GD32F30x\hal\inc; ..\..\..\..\platform\mcu\GD32F30x\Drivers\GD32F30x_standard_peripheral\Include; ..\..\..\..\drivers\GD32F30x; ..\..\..\..\platform\mcu\GD32F30x\Drivers\CMSIS\GD\GD32F30x\Include; ..\..\..\..\drivers\GD32F30x\inc; ..\..\..\..\platform\mcu\GD32F30x; ..\..\..\..\platform\arch; ..\..\..\..\middleware\frm; linked; archives
  OBJCOPY.OOCOutputFile: dehumi_watertankl-05.bin
  ILINK.IlinkIcfFile: icf\dehumi_watertank.icf
  group app
    app/: app.c drv_sys_tick.c pst_RF.c pst_zy.c public.c rfP2P.c tasks.c user_ctrl.c user_func.c wireless_proc.c wirelessSendCache.c
    linked/: LinkMng.c
    archives/: Nodes.c
  group app/other
    app/: alert.c core.c evt.c farp.c hlv.c inp.c netp.c netp2.c netp_fm.c pst.c pst_vs.c scan.c task.c
    ../../../../boot/src/: boot.c
    config/: msgid.c
  group drv
    ../../../../drivers/GD32F30x/: apis.c
    ../../../../drivers/GD32F30x/src/: dev_file.c dev_frm.c dev_gpi.c dev_gpo.c dev_ht1621.c dev_ht1621c.c dev_icm522.c dev_lcd_dsbk2348a.c dev_led.c dev_msgloop.c dev_realtime.c dev_rfA7139.c dev_rfid.c dev_uart2.c
  group hal
    ../../../../platform/mcu/GD32F30x/hal/src/: hal_flash.c hal_gpio.c hal_hwtimer.c hal_rtc.c hal_spiio2.c hal_uartx.c
    ../../../../platform/mcu/GD32F30x/hal/: hw.c
  group hal/chip
    ../../../../platform/mcu/GD32F30x/Drivers/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group lib
    ../../../../utility/lib_com/: calclib.c calclib_gw.c stream.c
    ../../../../drivers/GD32F30x/: extapi.c
  group lib/newlib_stub
    ../../../../utility/libc/compilers/iar/: iar_libc.c
  group MW/frm
    ../../../../middleware/frm/: frm.c
  group MW/log
    ../../../../middleware/log/: log.c
  group sys
    ../../../../platform/mcu/GD32F30x/aos/: aos.c hook_impl.c soc_impl.c
    ../../../../osal/aos/: common.c rhino.c
    ../../../../platform/mcu/stm32l4xx_cube/aos/: hook_impl.c soc_impl.c
  group sys/armv7m
    ../../../../platform/arch/arm/armv7m/common/: panic_c.c panic_iccarm.S port_c.c
    ../../../../platform/arch/arm/armv7m/iccarm/m4/: port_s.S
  group sys/board
    ../../../../board/GD32F30x-asw/Src/: main.c
    ../../../../board/GD32F30x-asw/aos/: soc_init.c
    ../../../../board/GD32F30x-asw/: startup_gd32f30x_cl.s startup_gd32f30x_hd.s
    ../../../../platform/mcu/GD32F30x/Drivers/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group sys/kernel_init
    ../../../../kernel/init/: aos_init.c
  group sys/rhino
    ../../../../kernel/rhino/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_spin_lock.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
