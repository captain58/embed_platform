<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\testL476_IAR_V7.ewp</path>
  </project>
  <batchBuild />
</workspace>
