# IAR project STM32L476RGTx.ewp, settings and files
configuration STM32L476RGTx (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L476xx; SYSINFO_OS_VERSION="APP-1.0.0"; SYSINFO_PRODUCT_MODEL="ALI_AOS_STM32L476RGTx"; SYSINFO_DEVICE_NAME="STM32L476RGTx"; SYSINFO_KERNEL_VERSION="AOS-R-1.3.3"; SYSINFO_APP_VERSION="APP-1.0.0"; STDIO_UART=0; CONFIG_NO_TCPIP; __BSD_VISIBLE; RHINO_CONFIG_TICK_TASK=0; _TIMESPEC_DEFINED; SAL_USE_AOS_HAL; AOS_ATCMD; _PLATFORM_ALIOS; WITH_SAL; AOS_COMP_ULOG
  ICCARM.CCDiagSuppress: Pe167,Pe144,Pe513,Pe177,Pe550,Pe188
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\kernel\rhino\include; ..\..\..\..\platform\arch\arm\armv7m\common; ..\..\..\..\platform\mcu\stm32l4xx_cube\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\platform\mcu\stm32l4xx_cube\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\platform\mcu\stm32l4xx_cube\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\platform\mcu\stm32l4xx_cube\Drivers\CMSIS\Include; ..\..\..\..\platform\mcu\stm32l4xx_cube\src\STM32L476RG-Nucleo\helloworld; ..\..\..\..\include\aos\hal; ..\..\..\..\network\yloop\include; ..\..\..\..\utility\libc\compilers\iar; ..\..\..\..\kernel\debug\include; ..\..\..\..\board\stm32l476rg-nucleo\aos; ..\..\..\..\kernel\debug; ..\..\..\..\middleware\uagent\ulog\include; ..\..\..\..\board\stm32l476rg-nucleo\hal; ..\..\..\..\board\stm32l476rg-nucleo\Inc; ..\..\..\..\board\stm32l476rg-nucleo; ..\..\..\..\network\nal\atparser; ..\..\..\..\middleware\linkkit\sdk-c\src\services\mdal\sal; ..\..\..\..\include\network; ..\..\..\..\kernel\init\include; ..\..\..\..\kernel\fs\kv\include; ..\..\..\..\kernel\fs\kv; ..\..\..\..\network\netmgr\include; ..\..\..\..\kernel\fs\vfs\include; ..\..\..\..\middleware\linkkit\sdk-c\src\services\mdal\sal\include; ..\..\..\..\kernel\fs\vfs; ..\..\..\..\network\yloop\hal; ..\..\..\..\drivers\sal\wifi\mk3060; ..\..\..\..\drivers\stm32L476; ..\..\..\..\drivers\stm32L476\inc; ..\..\..\..\drivers\sal; config; inc; app; ..\..\..\..\utility; ..\..\..\..\middleware\log; ..\..\..\..\middleware\atmodem; ..\..\..\..\utility\activation; ..\..\..\..\middleware\linkkit\sdk-c\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\..\board\stm32l476rg-nucleo\aos; ..\..\..\..\kernel\debug\include
  OBJCOPY.OOCOutputFile: STM32L476RGTx.srec
  ILINK.IlinkOutputFile: STM32L476RGTx.out
  ILINK.IlinkIcfFile: icf/stm32l476xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    app/: app.c farp.c pst.c pst_vs.c tasks.c
    ../../../../app/example/helloworld/: helloworld.c
    ../../../../middleware/log/: log.c
  group drv
    ../../../../drivers/stm32L476/src/: dev_frm.c dev_msgloop.c dev_realtime.c dev_uart2.c
  group lib
    ../../../../utility/lib_com/: calclib.c stream.c
  group lib/newlib_stub
    ../../../../utility/libc/compilers/iar/: iar_libc.c
    ../../../../utility/libc/: newlib_stub.c
  group MW/atparser
    ../../../../network/nal/atparser/: atparser.c atparser_arch.c
  group MW/debug
    ../../../../kernel/debug/: debug_backtrace.c debug_cpuusage.c debug_infoget.c debug_overview.c debug_panic.c
  group MW/device_sal_mk3060
    ../../../../middleware/atmodem/: atmodem.c modemlib.c
    ../../../../drivers/sal/wifi/mk3060/: mk3060.c wifi_atcmd.c
    ../../../../drivers/sal/gprs/ec20/: quectel_ec20.c
  group MW/kv
    ./: kernel_fs_kv_kv.c
    ../../../../kernel/fs/kv/: kv_adapt.c kv_cli.c
  group MW/netmgr
    ../../../../network/netmgr/: netmgr.c
    ../../../../network/netmgr/interfaces/: netmgr_wifi.c
    ../../../../network/netmgr/hal/: wifi.c
  group MW/ulog
    ../../../../middleware/uagent/ulog/: log.c ulog.c ulog_init.c
  group MW/vfs
    ./: kernel_fs_vfs_vfs.c
    ../../../../kernel/fs/vfs/: vfs_adapt.c vfs_file.c vfs_inode.c
  group MW/yloop
    ../../../../network/yloop/src/: device.c local_event.c select.c workqueue.c yloop.c
    ../../../../network/yloop/hal/: loop_hal_alios.c
  group sal
    ../../../../middleware/linkkit/sdk-c/src/services/mdal/sal/src/: ip4_addr.c sal_arch_aos.c sal_err.c sal_sockets.c
  group sys/arch_armv7m
    ../../../../platform/arch/arm/armv7m/common/: panic_c.c panic_iccarm.S port_c.c
    ../../../../platform/arch/arm/armv7m/iccarm/m4/: port_s.S
  group sys/board
    ../../../../board/stm32l476rg-nucleo/Src/: board_drv_led.c main.c stm32l4xx_hal_msp.c
    ../../../../board/stm32l476rg-nucleo/aos/: board_partition.c soc_init.c
    ../../../../board/stm32l476rg-nucleo/: startup_stm32l476xx.s startup_stm32l476xx_iar.s
  group sys/kernel_init
    ../../../../kernel/init/: aos_init.c
  group sys/mcu_stm32l4xx_cube
    ../../../../platform/mcu/stm32l4xx_cube/aos/: aos.c hook_impl.c rttest_impl.c soc_impl.c
    ../../../../platform/mcu/stm32l4xx_cube/hal/: hal_adc_stm32l4.c hal_flash_stm32l4.c hal_gpio_stm32l4.c hal_i2c_stm32l4.c hal_nand_stm32l4.c hal_nor_stm32l4.c hal_qspi_stm32l4.c hal_rtc_stm32l4.c hal_sd_stm32l4.c hal_spi_stm32l4.c hal_timer_stm32l4.c hal_uart_stm32l4.c hw.c
    ../../../../platform/mcu/stm32l4xx_cube/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dsi.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_msp_template.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_timebase_tim_template.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_adc.c stm32l4xx_ll_comp.c stm32l4xx_ll_crc.c stm32l4xx_ll_crs.c stm32l4xx_ll_dac.c stm32l4xx_ll_dma.c stm32l4xx_ll_dma2d.c stm32l4xx_ll_exti.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_swpmi.c stm32l4xx_ll_tim.c stm32l4xx_ll_usart.c stm32l4xx_ll_usb.c stm32l4xx_ll_utils.c
    ../../../../platform/mcu/stm32l4xx_cube/Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group sys/osal_aos
    ../../../../osal/aos/: common.c kv.c rhino.c vfs.c
  group sys/rhino
    ../../../../kernel/rhino/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_spin_lock.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group tcpip
    ../../../../middleware/linkkit/sdk-c/src/ref-impl/hal/os/alios/: HAL_AWSS_rhino.c HAL_Crypt_rhino.c HAL_DTLS_mbedtls.c HAL_FS_rhino.c HAL_OS_rhino.c HAL_PRODUCT_rhino.c HAL_TCP_rhino.c HAL_TLS_itls.c HAL_TLS_mbedtls.c HAL_UDP_rhino.c
